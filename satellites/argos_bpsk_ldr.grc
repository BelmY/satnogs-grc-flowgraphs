options:
  parameters:
    author: Manolis Surligas (surligas@gmail.com)
    description: ARGOS BPSK Low Data Rate Decoder
    generate_options: no_gui
    id: satnogs_argos_bpsk_ldr
    output_language: python
    run_options: run
    title: satnogs_argos_bpsk_ldr
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: avg_len
  id: variable
  parameters:
    comment: |-
      Moving average acting as a low pass filter
      to reduce the spurious of the VCO
    value: '2048'
  states: {}
- name: bpsk_constellation
  id: variable_constellation
  parameters:
    comment: |-
      To create a carrier at the center frequency, a DC bias can 
      be added to the BPSK constellation points.
      This technique is also known as residual carrier.
    const_points: '[-1+1j, 1+1j]'
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: decimation
  id: variable
  parameters:
    value: satnogs.find_decimation(baudrate, 2, audio_samp_rate,sps)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_argos_ldr_decoder_0
  id: variable_argos_ldr_decoder
  parameters:
    crc_check: 'True'
    frame_len: '64'
  states: {}
- name: variable_argos_ldr_decoder_0_0
  id: variable_argos_ldr_decoder
  parameters:
    crc_check: 'True'
    frame_len: '64'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.015'
    type: complex
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: 2*math.pi*max_cfo/(baudrate*decimation)
    min_freq: '-2*math.pi*max_cfo/(baudrate*decimation)'
    w: 2*math.pi/100
  states: {}
- name: antenna
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: baudrate
  id: parameter
  parameters:
    type: eng_float
    value: '800.0'
  states: {}
- name: bb_freq
  id: parameter
  parameters:
    label: Baseband CORDIC frequency (if the device supports it)
    type: eng_float
    value: '0.0'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: byte
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: avg_len // 2
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: byte
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      Simplified manchester decoding. Theoretically clock recovery has
      already performed and its performance should be better due to 
      the frequent transitions of the manchester encoding. 
      So after the clock recovery, nothing else can be done to improve
      timing, so we just drop 1 bit every 2 input bits.
    n: '2'
    type: byte
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: avg_len
    max_iter: '4000'
    scale: 1/avg_len
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Add a frequency offset equal the baudrate
      to move the audio representation of the
      signal to the audable frequencies
    phase_inc: 2.0 * math.pi * (baudrate / audio_samp_rate)
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: (baudrate*decimation)
    sensitivity: '-(baudrate*decimation)'
  states: {}
- name: bw
  id: parameter
  parameters:
    comment: |-
      The bandwidth should configure RF filters on some devices.
      Set to 0.0 for automatic calculation.
    label: Bandwidth
    type: eng_float
    value: '0.0'
  states: {}
- name: dc_removal
  id: parameter
  parameters:
    label: Remove automatically the DC offset (if the device support it)
    type: str
    value: '"False"'
  states: {}
- name: decoded_data_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/.satnogs/data/data"'
  states: {}
- name: dev_args
  id: parameter
  parameters:
    label: Device arguments
    type: str
    value: '""'
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: bpsk_constellation
    fmax: '0.125'
    fmin: '-0.125'
    loop_bw: 2.0 * math.pi/50.0
    showports: 'True'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2.0 * math.pi/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: doppler_correction_per_sec
  id: parameter
  parameters:
    type: intx
    value: '20'
  states: {}
- name: enable_iq_dump
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: excess_bw
  id: parameter
  parameters:
    comment: |-
      The BPSK excess bandwidth setup.
      Used in filtering.
    type: eng_float
    value: '0.5'
  states: {}
- name: file_path
  id: parameter
  parameters:
    type: str
    value: '"test.wav"'
  states: {}
- name: gain
  id: parameter
  parameters:
    comment: |-
      Generic gain value. 
      Each Soapy module
      will try to linearize this
      value by properly setting
      the device specific gains.
    type: eng_float
    value: '0.0'
  states: {}
- name: gain_mode
  id: parameter
  parameters:
    comment: |-
      Set the gain mode of the Soapy.
      Can be "Overall", "Specific"
      or "Settings Field"
    type: str
    value: '"Overall"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: iq_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/iq.dat"'
  states: {}
- name: lo_offset
  id: parameter
  parameters:
    comment: |-
      To avoid the SDR carrier at the DC
      we shift the LO a little further
    type: eng_float
    value: 100e3
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: baudrate/2 + excess_bw *baudrate/2 + 200
    decim: decimation // sps
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 10.0
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: ((1.0 + excess_bw) * baudrate/2.0) + min(baudrate, abs(max_cfo))
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_ccf
    width: baudrate / 10.0
    win: firdes.WIN_HAMMING
  states: {}
- name: max_cfo
  id: parameter
  parameters:
    comment: |-
      The maximum offset allowed from the carrier.
      Used for filtering. Larger values allow decoding
      of frames with large frequency drifts,
       but degrades  reception performance.
    type: eng_float
    value: '1000.0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Use the residual carrier to lock on and correct ant CFO
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: We do not know the phase of the bitstream, so we decode both possible bitstreams. The original and the delayed by one.
  states: {}
- name: other_settings
  id: parameter
  parameters:
    label: Soapy Channel other settings
    type: str
    value: '""'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '80'
    nfilts: '32'
    rrate: audio_samp_rate/(baudrate*decimation)
    type: ccf
  states: {}
- name: ppm
  id: parameter
  parameters:
    comment: |-
      The frequency correction in PPM
      to correct for a local oscillator frequency deviation
    type: eng_float
    value: '0'
  states: {}
- name: rigctl_port
  id: parameter
  parameters:
    type: intx
    value: '4532'
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 100e6
  states: {}
- name: samp_rate_rx
  id: parameter
  parameters:
    label: Device Sampling rate
    type: eng_float
    value: '0.0'
  states: {}
- name: satnogs_doppler_compensation_0
  id: satnogs_doppler_compensation
  parameters:
    compensate: '1'
    fine_correction: '0'
    lo_offset: lo_offset
    out_samp_rate: baudrate*decimation
    samp_rate: samp_rate_rx
    sat_freq: rx_freq
  states: {}
- name: satnogs_frame_decoder_0_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_argos_ldr_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_frame_decoder_0_0_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_argos_ldr_decoder_0_0
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_frame_file_sink_0_1_0
  id: satnogs_frame_file_sink
  parameters:
    output_type: '0'
    prefix_name: decoded_data_file_path
  states: {}
- name: satnogs_iq_sink_0_0
  id: satnogs_iq_sink
  parameters:
    activate: enable_iq_dump
    append: 'False'
    filename: iq_file_path
    scale: '16768'
  states: {}
- name: satnogs_json_converter_0
  id: satnogs_json_converter
  parameters:
    extra: ''
  states: {}
- name: satnogs_ogg_encoder_0
  id: satnogs_ogg_encoder
  parameters:
    filename: file_path
    quality: '1.0'
    samp_rate: audio_samp_rate
  states: {}
- name: satnogs_tcp_rigctl_msg_source_0
  id: satnogs_tcp_rigctl_msg_source
  parameters:
    addr: '"127.0.0.1"'
    interval: int(1000.0/doppler_correction_per_sec) + 1
    mode: 'False'
    mtu: '1500'
    port: rigctl_port
  states: {}
- name: satnogs_udp_msg_sink_0_0
  id: satnogs_udp_msg_sink
  parameters:
    addr: udp_IP
    mtu: '1500'
    port: udp_port
  states: {}
- name: satnogs_waterfall_sink_0_0
  id: satnogs_waterfall_sink
  parameters:
    center_freq: rx_freq
    fft_size: '1024'
    filename: waterfall_file_path
    mode: '1'
    rps: '10'
    samp_rate: baudrate*decimation
  states: {}
- name: soapy_rx_device
  id: parameter
  parameters:
    type: str
    value: '"driver=invalid"'
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: antenna
    args: dev_args
    balance0: '0'
    bw0: bw
    center_freq0: rx_freq - lo_offset
    correction0: ppm
    dc_offset0: '0'
    dc_removal0: dc_removal
    dev: soapy_rx_device
    devname: custom
    gain_mode0: gain_mode
    nco_freq0: bb_freq
    overall_gain0: gain
    samp_rate: samp_rate_rx
    sdrplay_biastee: 'True'
    settings0: other_settings
    stream_args: stream_args
    tune_args0: tune_args
    type: fc32
  states: {}
- name: stream_args
  id: parameter
  parameters:
    label: Soapy Stream arguments
    type: str
    value: '""'
  states: {}
- name: tune_args
  id: parameter
  parameters:
    label: Soapy Channel Tune arguments
    type: str
    value: '""'
  states: {}
- name: udp_IP
  id: parameter
  parameters:
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: udp_port
  id: parameter
  parameters:
    type: intx
    value: '16887'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: doppler_corrected
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: doppler_corrected
  states: {}
- name: waterfall_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/waterfall.dat"'
  states: {}

connections:
- [analog_agc2_xx_0, '0', analog_pll_freqdet_cf_0, '0']
- [analog_agc2_xx_0, '0', blocks_delay_1, '0']
- [analog_agc2_xx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [analog_agc2_xx_0_0, '0', low_pass_filter_0_0, '0']
- [analog_pll_freqdet_cf_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_real_0, '0', satnogs_ogg_encoder_0, '0']
- [blocks_delay_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_delay_1, '0', blocks_multiply_xx_0_0, '0']
- [blocks_keep_one_in_n_0, '0', satnogs_frame_decoder_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', satnogs_frame_decoder_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_rotator_cc_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0_0, '1']
- [digital_constellation_receiver_cb_0, '0', blocks_delay_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_keep_one_in_n_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_constellation_receiver_cb_0, '0']
- [low_pass_filter_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [low_pass_filter_0_0, '0', blocks_rotator_cc_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', analog_agc2_xx_0_0, '0']
- [satnogs_doppler_compensation_0, '0', virtual_sink_0, '0']
- [satnogs_frame_decoder_0_0, out, satnogs_json_converter_0, in]
- [satnogs_frame_decoder_0_0_0, out, satnogs_json_converter_0, in]
- [satnogs_json_converter_0, out, satnogs_frame_file_sink_0_1_0, frame]
- [satnogs_json_converter_0, out, satnogs_udp_msg_sink_0_0, in]
- [satnogs_tcp_rigctl_msg_source_0, freq, satnogs_doppler_compensation_0, doppler]
- [soapy_source_0, '0', satnogs_doppler_compensation_0, '0']
- [virtual_source_0, '0', analog_agc2_xx_0, '0']
- [virtual_source_0, '0', satnogs_iq_sink_0_0, '0']
- [virtual_source_0, '0', satnogs_waterfall_sink_0_0, '0']

metadata:
  file_format: 1
