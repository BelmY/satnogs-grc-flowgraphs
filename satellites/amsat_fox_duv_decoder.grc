options:
  parameters:
    author: Thanos Giolias (agiolias@csd.uoc.gr), Nikos Karamolegos (karamolegkos.n@gmail.com), Manolis Surligas (surligas@gmail.com)
    category: Custom
    description: A DUV Decoder for the AMSAT FOX satellites
    generate_options: no_gui
    id: satnogs_amsat_fox_duv_decoder
    output_language: python
    run_options: run
    title: AMSAT FOX DUV Decoder
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: max_modulation_freq
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: variable_amsat_duv_decoder_0
  id: variable_amsat_duv_decoder
  parameters:
    control_symbol: '0011111010'
    frame_len: '96'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.9'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.2'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: antenna
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: bb_freq
  id: parameter
  parameters:
    label: Baseband CORDIC frequency (if the device supports it)
    type: eng_float
    value: '0.0'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(1024/2)
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1024'
    max_iter: '4096'
    scale: 1.0/1024.0
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: audio_samp_rate
    sensitivity: '-audio_samp_rate'
  states: {}
- name: bw
  id: parameter
  parameters:
    comment: |-
      The bandwidth should configure RF filters on some devices.
      Set to 0.0 for automatic calculation.
    label: Bandwidth
    type: eng_float
    value: '0.0'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_removal
  id: parameter
  parameters:
    label: Remove automatically the DC offset (if the device support it)
    type: str
    value: '"False"'
  states: {}
- name: decoded_data_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/.satnogs/data/data"'
  states: {}
- name: dev_args
  id: parameter
  parameters:
    label: Device arguments
    type: str
    value: '""'
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: (audio_samp_rate/100.0) / 200
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: doppler_correction_per_sec
  id: parameter
  parameters:
    type: intx
    value: '20'
  states: {}
- name: enable_iq_dump
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: file_path
  id: parameter
  parameters:
    type: str
    value: '"test.wav"'
  states: {}
- name: gain
  id: parameter
  parameters:
    comment: |-
      Generic gain value. 
      Each Soapy module
      will try to linearize this
      value by properly setting
      the device specific gains.
    type: eng_float
    value: '0.0'
  states: {}
- name: gain_mode
  id: parameter
  parameters:
    comment: |-
      Set the gain mode of the Soapy.
      Can be "Overall", "Specific"
      or "Settings Field"
    type: str
    value: '"Overall"'
  states: {}
- name: iq_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/iq.dat"'
  states: {}
- name: lo_offset
  id: parameter
  parameters:
    comment: |-
      To avoid the SDR carrier at the DC
      we shift the LO a little further
    type: eng_float
    value: 100e3
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: max_modulation_freq
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: max_modulation_freq
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '195'
    decim: '100'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: other_settings
  id: parameter
  parameters:
    label: Soapy Channel other settings
    type: str
    value: '""'
  states: {}
- name: ppm
  id: parameter
  parameters:
    comment: |-
      The frequency correction in PPM
      to correct for a local oscillator frequency deviation
    type: eng_float
    value: '0'
  states: {}
- name: rigctl_port
  id: parameter
  parameters:
    type: intx
    value: '4532'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: '512'
    samp_rate: '1'
    sym_rate: '2.4'
    type: fir_filter_fff
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 100e6
  states: {}
- name: samp_rate_rx
  id: parameter
  parameters:
    label: Device Sampling rate
    type: eng_float
    value: '0.0'
  states: {}
- name: satnogs_doppler_compensation_0
  id: satnogs_doppler_compensation
  parameters:
    compensate: '1'
    fine_correction: '0'
    lo_offset: lo_offset
    out_samp_rate: audio_samp_rate
    samp_rate: samp_rate_rx
    sat_freq: rx_freq
  states: {}
- name: satnogs_frame_decoder_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_amsat_duv_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_frame_file_sink_0_1_0
  id: satnogs_frame_file_sink
  parameters:
    output_type: '0'
    prefix_name: decoded_data_file_path
  states: {}
- name: satnogs_iq_sink_0
  id: satnogs_iq_sink
  parameters:
    activate: enable_iq_dump
    append: 'False'
    filename: iq_file_path
    scale: '16768'
  states: {}
- name: satnogs_json_converter_0
  id: satnogs_json_converter
  parameters:
    extra: ''
  states: {}
- name: satnogs_ogg_encoder_0
  id: satnogs_ogg_encoder
  parameters:
    filename: file_path
    quality: '1.0'
    samp_rate: audio_samp_rate
  states: {}
- name: satnogs_tcp_rigctl_msg_source_0
  id: satnogs_tcp_rigctl_msg_source
  parameters:
    addr: '"127.0.0.1"'
    interval: int(1000.0/doppler_correction_per_sec) + 1
    mode: 'False'
    mtu: '1500'
    port: rigctl_port
  states: {}
- name: satnogs_udp_msg_sink_0_0
  id: satnogs_udp_msg_sink
  parameters:
    addr: udp_IP
    mtu: '1500'
    port: udp_port
  states: {}
- name: satnogs_waterfall_sink_0
  id: satnogs_waterfall_sink
  parameters:
    center_freq: rx_freq
    fft_size: '1024'
    filename: waterfall_file_path
    mode: '1'
    rps: '10'
    samp_rate: audio_samp_rate
  states: {}
- name: soapy_rx_device
  id: parameter
  parameters:
    type: str
    value: '"driver=invalid"'
  states: {}
- name: soapy_source_0_0
  id: soapy_source
  parameters:
    ant0: antenna
    args: dev_args
    balance0: '0'
    bw0: bw
    center_freq0: rx_freq - lo_offset
    correction0: ppm
    dc_offset0: '0'
    dc_removal0: dc_removal
    dev: soapy_rx_device
    devname: custom
    gain_mode0: gain_mode
    nco_freq0: bb_freq
    overall_gain0: gain
    samp_rate: samp_rate_rx
    sdrplay_biastee: 'True'
    settings0: other_settings
    stream_args: stream_args
    tune_args0: tune_args
    type: fc32
  states: {}
- name: stream_args
  id: parameter
  parameters:
    label: Soapy Stream arguments
    type: str
    value: '""'
  states: {}
- name: tune_args
  id: parameter
  parameters:
    label: Soapy Channel Tune arguments
    type: str
    value: '""'
  states: {}
- name: udp_IP
  id: parameter
  parameters:
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: udp_port
  id: parameter
  parameters:
    type: intx
    value: '16887'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: doppler_corrected
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: doppler_corrected
  states: {}
- name: waterfall_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/waterfall.dat"'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', satnogs_ogg_encoder_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', low_pass_filter_1, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0_0, '1']
- [dc_blocker_xx_0, '0', root_raised_cosine_filter_0, '0']
- [digital_binary_slicer_fb_0_0, '0', satnogs_frame_decoder_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [low_pass_filter_1, '0', dc_blocker_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_clock_recovery_mm_xx_0_0_0, '0']
- [satnogs_doppler_compensation_0, '0', virtual_sink_0, '0']
- [satnogs_frame_decoder_0, out, satnogs_json_converter_0, in]
- [satnogs_json_converter_0, out, satnogs_frame_file_sink_0_1_0, frame]
- [satnogs_json_converter_0, out, satnogs_udp_msg_sink_0_0, in]
- [satnogs_tcp_rigctl_msg_source_0, freq, satnogs_doppler_compensation_0, doppler]
- [soapy_source_0_0, '0', satnogs_doppler_compensation_0, '0']
- [virtual_source_0, '0', blocks_delay_0, '0']
- [virtual_source_0, '0', low_pass_filter_0_0, '0']
- [virtual_source_0, '0', satnogs_iq_sink_0, '0']
- [virtual_source_0, '0', satnogs_waterfall_sink_0, '0']

metadata:
  file_format: 1
