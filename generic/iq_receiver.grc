options:
  parameters:
    author: Manolis Surligas (surligas@gmail.com)
    description: Generic IQ receiver with arbitrary output sampling rate
    generate_options: no_gui
    id: satnogs_iq_receiver
    output_language: python
    run_options: run
    title: satnogs_iq_receiver
  states: {}

blocks:
- name: antenna
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: bb_freq
  id: parameter
  parameters:
    label: Baseband CORDIC frequency (if the device supports it)
    type: eng_float
    value: '0.0'
  states: {}
- name: bw
  id: parameter
  parameters:
    comment: |-
      The bandwidth should configure RF filters on some devices.
      Set to 0.0 for automatic calculation.
    label: Bandwidth
    type: eng_float
    value: '0.0'
  states: {}
- name: dc_removal
  id: parameter
  parameters:
    label: Remove automatically the DC offset (if the device support it)
    type: str
    value: '"False"'
  states: {}
- name: dev_args
  id: parameter
  parameters:
    label: Device arguments
    type: str
    value: '""'
  states: {}
- name: doppler_correction_per_sec
  id: parameter
  parameters:
    type: intx
    value: '20'
  states: {}
- name: enable_doppler_correction
  id: parameter
  parameters:
    type: intx
    value: '1'
  states: {}
- name: enable_iq_dump
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: file_path
  id: parameter
  parameters:
    type: str
    value: '"test.wav"'
  states: {}
- name: gain
  id: parameter
  parameters:
    comment: |-
      Generic gain value. 
      Each Soapy module
      will try to linearize this
      value by properly setting
      the device specific gains.
    type: eng_float
    value: '0.0'
  states: {}
- name: gain_mode
  id: parameter
  parameters:
    comment: |-
      Set the gain mode of the Soapy.
      Can be "Overall", "Specific"
      or "Settings Field"
    type: str
    value: '"Overall"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: iq_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/iq.dat"'
  states: {}
- name: lo_offset
  id: parameter
  parameters:
    comment: |-
      To avoid the SDR carrier at the DC
      we shift the LO a little further
    type: eng_float
    value: 100e3
  states: {}
- name: other_settings
  id: parameter
  parameters:
    label: Soapy Channel other settings
    type: str
    value: '""'
  states: {}
- name: out_samp_rate
  id: parameter
  parameters:
    label: Output sampling rate
    type: eng_float
    value: '0.0'
  states: {}
- name: ppm
  id: parameter
  parameters:
    comment: |-
      The frequency correction in PPM
      to correct for a local oscillator frequency deviation
    type: eng_float
    value: '0'
  states: {}
- name: rigctl_port
  id: parameter
  parameters:
    type: intx
    value: '4532'
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 100e6
  states: {}
- name: samp_rate_rx
  id: parameter
  parameters:
    label: Device Sampling rate
    type: eng_float
    value: '0.0'
  states: {}
- name: satnogs_doppler_compensation_0
  id: satnogs_doppler_compensation
  parameters:
    compensate: enable_doppler_correction
    fine_correction: '0'
    lo_offset: lo_offset
    out_samp_rate: out_samp_rate
    samp_rate: samp_rate_rx
    sat_freq: rx_freq
  states: {}
- name: satnogs_iq_sink_0
  id: satnogs_iq_sink
  parameters:
    activate: enable_iq_dump
    append: 'False'
    filename: iq_file_path
    scale: '16768'
  states: {}
- name: satnogs_tcp_rigctl_msg_source_0
  id: satnogs_tcp_rigctl_msg_source
  parameters:
    addr: '"127.0.0.1"'
    interval: int(1000.0/doppler_correction_per_sec) + 1
    mode: 'False'
    mtu: '1500'
    port: rigctl_port
  states: {}
- name: satnogs_waterfall_sink_0
  id: satnogs_waterfall_sink
  parameters:
    center_freq: rx_freq
    fft_size: '1024'
    filename: waterfall_file_path
    mode: '1'
    rps: '10'
    samp_rate: out_samp_rate
  states: {}
- name: soapy_rx_device
  id: parameter
  parameters:
    type: str
    value: '"driver=invalid"'
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: antenna
    args: dev_args
    balance0: '0'
    bw0: bw
    center_freq0: rx_freq - lo_offset
    correction0: ppm
    dc_offset0: '0'
    dc_removal0: dc_removal
    dev: soapy_rx_device
    devname: custom
    gain_mode0: gain_mode
    nco_freq0: bb_freq
    overall_gain0: gain
    samp_rate: samp_rate_rx
    sdrplay_biastee: 'True'
    settings0: other_settings
    stream_args: stream_args
    tune_args0: tune_args
    type: fc32
  states: {}
- name: stream_args
  id: parameter
  parameters:
    label: Soapy Stream arguments
    type: str
    value: '""'
  states: {}
- name: tune_args
  id: parameter
  parameters:
    label: Soapy Channel Tune arguments
    type: str
    value: '""'
  states: {}
- name: waterfall_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/waterfall.dat"'
  states: {}

connections:
- [satnogs_doppler_compensation_0, '0', satnogs_iq_sink_0, '0']
- [satnogs_doppler_compensation_0, '0', satnogs_waterfall_sink_0, '0']
- [satnogs_tcp_rigctl_msg_source_0, freq, satnogs_doppler_compensation_0, doppler]
- [soapy_source_0, '0', satnogs_doppler_compensation_0, '0']

metadata:
  file_format: 1
